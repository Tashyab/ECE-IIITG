# Keil uVision project USBFS_UART01_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(0) MODDP2"
  output: USBFS_UART01_PSoC3lib (library)
  c flags: Optimize=2
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x1FFF)) CL(CODE(C:0x0000-C:0xFFFF)) CL(CONST(C:0x0000-C:0xFFFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc CyScBoostClk.c CyScBoostClk.h cyfitter.h cydisabledsheets.h USBUART.c USBUART.h USBUART_audio.c USBUART_audio.h USBUART_boot.c USBUART_cdc.c USBUART_cdc.h USBUART_cls.c USBUART_descr.c USBUART_drv.c USBUART_episr.c USBUART_hid.c USBUART_hid.h USBUART_pm.c USBUART_std.c USBUART_vnd.c USBUART_cdc.inf USBUART_midi.c USBUART_midi.h USBUART_pvt.h USBUART_cydmac.h USBUART_msc.c USBUART_msc.h LCD.c LCD.h LCD_PM.c USBUART_Dm.c USBUART_Dm.h USBUART_Dm_aliases.h USBUART_Dp.c USBUART_Dp.h USBUART_Dp_aliases.h LCD_LCDPort.c LCD_LCDPort.h LCD_LCDPort_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc cy_em_eeprom.c cy_em_eeprom.h project.h cycodeshareimport.ld cycodeshareexport.ld cycodeshareimport.scat
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(0) MODDP2"
  output: USBFS_UART01_PSoC3lib (library)
  c flags: Optimize=5 SizeSpeed=1
  c define: NDEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
